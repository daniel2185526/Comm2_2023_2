options:
  parameters:
    generate_options: qt_gui
    id: COmandoPython
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (1, -3, 4, -16, 8)
  states: {}
- name: e_cum
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='e_Acum',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              

          def work(self, input_items, output_items):
             x=input_items[0]
             y0=output_items[0]
             y0[:]=np.cumsum(x)
              return len(y)
    example_param: '1.0'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    nconnections: '2'
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}

connections:
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
